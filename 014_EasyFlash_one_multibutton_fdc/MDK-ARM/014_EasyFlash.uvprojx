# Keil uVision project 014_EasyFlash.uvprojx, settings and files
target 014_EasyFlash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: 014_EasyFlash +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Package; ..\Package\multi_button; ..\Package\RingBuffer; ..\Package\sfud\inc; ..\Package\easyflash\inc; ..\Drivers\IIC; ..\Drivers\FDC2214; ..\User\operatingfdc; ..\User\operatingflash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../User/operatingfdc/: operatingfdc.c
    ../User/operatingflash/: operatingflash.c
    ../Src/: main.c gpio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Package/SFUD
    ../Package/sfud/port/: sfud_port.c
    ../Package/sfud/src/: sfud.c sfud_sfdp.c
  group Package/MultiButton
    ../Package/multi_button/: multi_button.c
  group Package/RingBuffer
    ../Package/RingBuffer/: ringbuffer.c
  group Package/EasyFlash
    ../Package/easyflash/port/: ef_port.c
    ../Package/easyflash/src/: easyflash.c ef_env.c ef_utils.c
  group Drivers
    ../Drivers/IIC/: iic.c
    ../Drivers/FDC2214/: FDC2214.c
software components: CMSIS:CORE 4.3.0
